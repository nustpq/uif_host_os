# IAR project AT91SAM7A3-OS-Probe.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: AT91SAM7A3 Atmel AT91SAM7A3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\uC-CPU\ARM\IAR; ..\BSP; ..\Driver; ..\Noah; ..\Shell; ..\uCOS-II\Source; ..\uC-CPU; ..\uC-LIB; ..\uC-CPU\ARM\IAR; ..\uCOS-II\Ports\ARM\Generic\IAR; ..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\uC-Probe\Target\Communication\Generic\RS-232\Ports\Atmel\AT91SAM7X; ..\uC-Probe\Target\Communication\Generic\Source; ..\uC-Probe\Target\Plugins\uCOS-II; ..\uC-Probe\Target\Demos\Intro\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UIF_Host_V.bin
  ILINK.IlinkOutputFile: AT91SAM7X256-OS-Probe-v5-2.out
  ILINK.IlinkIcfFile: ..\BSP\AT91SAM7A3_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./: app.c app_cfg.h app_hooks.c app_probe.c app_probe.h cpu_cfg.h includes.h os_cfg.h probe_com_cfg.h task_cmd_parse.c task_joy.c task_noah.c task_noah_ruler.c task_shell.c task_uart_rx.c task_uart_tx.c task_uart_tx_ruler.c task_user_if.c taskcomm.h
  group BSP
    ../BSP/: at91sam7a3.h AT91SAM7A3_Flash.icf AT91SAM7A3_Flash.mac board.h bsp.c bsp.h cstartup.s Xmodem.c Xmodem.h
  group Driver
    ../Driver/: async.c async.h codec.c codec.h efc.c efc.h flashd.h flashd_efc.c gpio.c gpio.h led.c led.h math.c math.h pio.c pio.h pio_it.c pio_it.h queue.c queue.h spi.c spi.h timer.c timer.h twi.c twi.h twid.c twid.h uart.c uart.h
  group NOAH
    ../Noah/: dsp.c dsp.h emb.c emb.h mem_basic.c mem_basic.h noah_cmd.c noah_cmd.h ruler.c ruler.h uif.c uif.h
  group Shell
    ../Shell/: commands.c commands.h
  group uC/CPU/ARM
    ../uC-CPU/ARM/IAR/: cpu.h cpu_a.s
    ../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM/IAR
    ../uC-LIB/Ports/ARM/IAR/: lib_mem_a.asm
  group uC/OS-II/Port
    ../uCOS-II/Ports/ARM/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group uC/OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/Probe/Target/Communication/OS/uCOS-II
    ../uC-Probe/Target/Communication/Generic/OS/uCOS-II/: probe_com_os.c
  group uC/Probe/Target/Communication/RS-232/OS/uCOS-II
    ../uC-Probe/Target/Communication/Generic/RS-232/OS/uCOS-II/: probe_rs232_os.c
  group uC/Probe/Target/Communication/RS-232/Port
    ../uC-Probe/Target/Communication/Generic/RS-232/Ports/Atmel/AT91SAM7X/: probe_rs232c.c probe_rs232c.h
  group uC/Probe/Target/Communication/RS-232/Source
    ../uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.c probe_rs232.h
  group uC/Probe/Target/Communication/Source
    ../uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uC/Probe/Target/Demo/Intro
    ../uC-Probe/Target/Demos/Intro/Source/: probe_demo_intro.c probe_demo_intro.h
  group uC/Probe/Target/Demo/Workspaces
    ../uC-Probe/Target/Demos/Intro/Workspaces/: Probe-Demo-Intro-Workspace.wsp
  group uC/Probe/Target/Plugin/uCOS-II
    ../uC-Probe/Target/Plugins/uCOS-II/: os_probe.c os_probe.h
