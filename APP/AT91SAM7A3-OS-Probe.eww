<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AT91SAM7A3-OS-Probe.ewp</path>
  </project>
  <batchBuild/>
</workspace>


